# Repository Lana-chan/brochehacker

File README.md:

# brochehacker
Design de um broche animado com LEDs

Design files for a LED pin badge

[See it in action](https://img.maple.pet/i/3e0.mp4)!

## KiCad design board/brochehacker.kicad_pcb

Parts:
D1: DISP_LED_MAT_8x8_COM_CAT; LED_8x8_3MM_32x32MM
IC1: ATMEGA328-P; DIP-28_W7.62mm_LongPads
JP1: JUMPER; Pin_Header_Straight_1x02
P1: CONN_01X02; Pin_Header_Straight_1x02
P2: CONN_01X03; Pin_Header_Straight_1x03
R1: 10k; Resistor_Horizontal_RM7mm
SW1, SW2, SW3, SW4: SW_PUSH; SW_PUSH_SMALL

Connections:
/COL1: D1.13 (C1), IC1.25 ((PCINT10/ADC2)PC2)
/COL2: D1.3 (C2), IC1.4 ((PCINT18/INT0)PD2)
/COL3: D1.4 (C3), IC1.5 ((PCINT19/OC2B/INT1)PD3)
/COL4: D1.10 (C4), IC1.16 ((PCINT2/OC1B/~SS~)PB2)
/COL5: D1.6 (C5), IC1.12 ((PCINT22/OC0A/AIN0)PD6)
/COL6: D1.11 (C6), IC1.23 ((PCINT8/ADC0)PC0)
/COL7: D1.15 (C7), IC1.27 ((PCINT12/SDA/ADC4)PC4)
/COL8: D1.16 (C8), IC1.28 ((PCINT13/SCL/ADC5)PC5)
/ROW1: D1.9 (R1), IC1.15 ((PCINT1/OC1A)PB1)
/ROW2: D1.14 (R2), IC1.26 ((PCINT11/ADC3)PC3)
/ROW3: D1.8 (R3), IC1.14 ((PCINT0/CLKO/ICP1)PB0)
/ROW4: D1.12 (R4), IC1.24 ((PCINT9/ADC1)PC1)
/ROW5: D1.1 (R5), IC1.2 ((PCINT16/RXD)PD0), P2.2
/ROW6: D1.7 (R6), IC1.13 ((PCINT23/AIN1)PD7)
/ROW7: D1.2 (R7), IC1.3 ((PCINT17/TXD)PD1), P2.3
/ROW8: D1.5 (R8), IC1.11 ((PCINT21/OC0B/T1)PD5)
GND: IC1.8 (GND), IC1.22 (GND), P1.2, SW1.2, SW2.2, SW3.2, SW4.2
unnamed: IC1.6 ((PCINT20/XCK/T0)PD4), SW4.1
unnamed: IC1.17 ((PCINT3/OC2A/MOSI)PB3), SW1.1
unnamed: IC1.18 ((PCINT4/MISO)PB4), SW2.1
unnamed: IC1.19 ((PCINT5/SCK)PB5), SW3.1
VCC: IC1.7 (VCC), IC1.20 (AVCC), P1.1, R1.1

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
Board: 2 copper layers, 38.7 x 40.0 mm, 9 parts (0 on the bottom side), 23 nets.

## KiCad design brochehacker.kicad_pcb

Parts:
D1: DISP_LED_MAT_8x8_COM_CAT; LED_8x8_3MM_32x32MM
IC1: ATTINY85-P; DIP-8_W7.62mm
P1: CONN_01X02; Pin_Header_Straight_1x02
R1: 10k; Resistor_Horizontal_RM7mm
U1: MAX7219; DIP-24_W7.62mm

Connections:
/DIG0: D1.9 (R1), U1.2 (DIG0)
/DIG1: D1.14 (R2), U1.11 (DIG1)
/DIG2: D1.8 (R3), U1.6 (DIG2)
/DIG3: D1.12 (R4), U1.7 (DIG3)
/DIG4: D1.1 (R5), U1.3 (DIG4)
/DIG5: D1.7 (R6), U1.10 (DIG5)
/DIG6: D1.2 (R7), U1.5 (DIG6)
/DIG7: D1.5 (R8), U1.8 (DIG7)
/SEGA: D1.3 (C2), U1.14 (SEGA)
/SEGB: D1.4 (C3), U1.16 (SEGB)
/SEGC: D1.10 (C4), U1.20 (SEGC)
/SEGD: D1.6 (C5), U1.23 (SEGD)
/SEGDP: D1.13 (C1), U1.22 (SEGDP)
/SEGE: D1.11 (C6), U1.21 (SEGE)
/SEGF: D1.15 (C7), U1.15 (SEGF)
/SEGG: D1.16 (C8), U1.17 (SEGG)
GND: IC1.4 (GND), P1.2, U1.4 (GND), U1.9 (GND)
unnamed: IC1.2 (PB3(XTAL1/CLKI/OC1B/ADC3/PCINT3)), U1.12 (LOAD)
unnamed: IC1.3 (PB4(XTAL2/CLKO/OC1B/ADC2/PCINT4)), U1.13 (CLK)
unnamed: IC1.5 (PB0(MOSI/DI/SDA/AIN0/OC0A/OC1A/AREF/PCI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), U1.1 (DIN)
unnamed: R1.2, U1.18 (ISET)
VCC: IC1.8 (VCC), P1.1, R1.1, U1.19 (VCC)

Board: 2 copper layers, 33.0 x 33.7 mm, 5 parts (1 on the bottom side), 22 nets.

## Commit log

2016-07-28 PCB roteada
2016-07-28 conserta traço perto de pad
2016-07-29 correção da orientação do display
2016-07-29 adição de espaço em cobre para soldar um alfinete
2016-08-01 move placa, mudanças em traços, silk, gerbers
2016-08-01 código arduino
2016-08-01 remove zip desatualizado
2016-08-01 adição de chave de força
2016-08-01 correção do silk
2016-08-01 comentário sobre delay
2016-08-03 modificação na ilha de cobre
2016-08-03 versão camada simples
2016-08-03 gerbers camada simples
2016-08-03 código para nova placa
2016-08-04 conserta cristal e reajusta jumpers
2016-08-08 novo código, requer timerone
2016-08-09 remove cristal, adiciona botões
2016-08-09 novos gerbers
2016-08-10 novos pads de alfinete
2016-08-10 gerbers
2016-08-10 código para botões
2016-08-12 refatora código singlesided
2016-08-12 compilável
2016-08-13 teste de peças de tetris
2016-08-14 rotinas de colisão rudimentares
2016-08-15 mais colisões, não-funcional
2016-08-15 tetris quase funcional
2016-08-15 corrige colisões, volta pra glider em gameover
2016-08-15 tetris minimamente funcional, pronto para merge
2016-08-15 tetris mais leniente
2016-08-31 adaptado para matriz de ânodo comum (1088BS)
2016-08-31 nova animação
    to-do: sistema mais arbitrário
2016-08-31 função de texto scroll inacabada
2016-08-31 fix lookup do texto, scroll funcionando
2016-09-05 mudanças de botões
2016-09-07 remoção de jumper e traços mais grossos
2016-10-18 small comment revisions
2016-10-18 moving files to avoid future conflicts
2016-10-18 eeprom storage sketching
2016-10-18 substitui defaults por eeprom
2016-10-18 fix referências a estrutura
2016-10-18 serial implementado para texto
2016-10-18 serial para anim e fix consts de tetris
2016-11-21 modo serial indicado e fix load
2016-11-25 fix carregar anim
2016-11-25 implementa dump da eeprom
2016-11-29 tilde a hack, plus minus chars
2016-12-07 bugfix serial
